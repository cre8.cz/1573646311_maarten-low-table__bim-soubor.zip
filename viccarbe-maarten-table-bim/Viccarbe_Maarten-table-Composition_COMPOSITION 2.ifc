Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2016-07-25T16:14:58
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20140223_1515(x64) - Exporter 15.6.0.0 - Alternate UI 15.6.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Mon Jul 25 16:14:58 2016 * Host: Bestia-01 * Database: C:\Users\CARLOS~1\AppData\Local\Temp\{0757D188-BBA4-42D1-883C-93CD78A421CB}\ifc * Database version: 5507 * Database creation date: Mon Jul 25 16:14:57 2016 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Mon Jul 25 16:14:57 2016 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Mon Jul 25 16:14:57 2016 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Nombre de proyecto; Phase: Estado de proyecto

# IfcSite, Default
RefLatitude: 40, 23, 59, 999999; RefLongitude: -3, -40, -59, -879999; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Propietario; Project Address: Introduzca dirección aquí; Project Issue Date: Fecha de emisión; Project Name: Nombre de proyecto; Project Number: 0001; Project Status: Estado de proyecto

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information; Client Name: Propietario; Project Address: Introduzca dirección aquí; Project Issue Date: Fecha de emisión; Project Name: Nombre de proyecto; Project Number: 0001; Project Status: Estado de proyecto

# IfcBuildingStorey, Nivel 1
LongName: Nivel 1; Elevation: 0 mm
Other - Category: Levels; Family Name: Level; Family: Level: Extremo inicial 8 mm; Family and Type: Level: Extremo inicial 8 mm; Type: Level: Extremo inicial 8 mm; Type Id: Level: Extremo inicial 8 mm
Identity Data - Type Name: Extremo inicial 8 mm; Building Story: yes; Name: Nivel 1; Structural: no
Graphics - Color: 0; Line Pattern: Solid; Line Weight: 1; Symbol: Extremo inicial de nivel - Círculo: Extremo inicial de nivel - Círculo; Symbol at End 1 Default: no; Symbol at End 2 Default: yes
Constraints - Elevation Base: Project Base Point; Elevation: 0 mm
Dimensions - Computation Height: 0 mm

# IfcFurnishingElement: COMPOSITION 2, 2015_Table_Viccarbe_Maarten-Composition:COMPOSITION 2:137235
In: Nivel 1
Type - ElementType: COMPOSITION 2; Material: Lacquered MDF -Black, Steel lacquered in thermoset epoxy, Lacquered MDF -White RAL9003
Type - Construction - Maarten Leaned Return Table 180x80: yes; Maarten Leaned Return Table 180x80 - 2: no; Maarten Leaned Table 180x80: no; Maarten Leaned Table 180x80 - 2: no; Storage Unit 800 With Shelf and Doors: no; Storage Unit 800 With Shelf and Doors - 2: no; Storage Unit For CPU With Door: yes
Type - Dimensions - Depth (inches): 70.87"; Depth (mm): 1800 mm; Height (inches): 27.95"; Height (mm): 740 mm; Width (inches): 49.21"; Width (mm): 1250 mm
Type - Identity Data - Bimetica: http://www.bimetica.com/; Collection: MAARTEN TABLE; Content Revision Date: 05/07/2016; Created by: Bimetica Parametric Design Services, S.L.; Description: Table system is based on a technical minimalist leg solution that does not need a structure and can be attached directly to the table top. Having no structure and a table top thickness of just 5 mm it acquires great visual lightness. There are endless uses, finishes and formats with this innovative system. Its “one mile” concept expresses how it can be used for breakfast in the kitchen, then working in the office, for eating in its restaurant version and later on for a meeting around it as a boardroom table and finally for dinner in the evening.; Designer: VICTOR CARRASCO; Essays BIFMA: -; Essays UNE: http://www.viccarbe.com/archivos/viccarbe-test-maarten-(table)-14.pdf; General Dimensions (inches): 70.87"x49.21"x27.95"; General Dimensions (mm): 1800x1250x740 mm; Information Expiry Date: 01/01/2017; Manufacturer: VICCARBE; Model: COMPOSITION 2; OmniClass Number: 23.40.20.00; OmniClass Title: General Furniture and Specialties; Product Contact Email: info@viccarbe.com; Product Contact Telephone: +34 96 120 10 10; Product URL: http://www.viccarbe.com/product.php?id=21534669d86a5d4; Reference Code: -; Series: OFFICE; Technical information: http://www.viccarbe.com/archivos/viccarbe-maarten-table-en-info-49.pdf; Terms and Conditions of Sale: See the conditions on the pricelist.; Type Name: COMPOSITION 2; URL: http://www.viccarbe.com/; Warranty: 5 YEARS; Warranty URL: http://www.viccarbe.com/quality.php
Type - Materials and Finishes - Materials - Lacquers: http://www.viccarbe.com/archivos/VICCARBE_lacquers_lacados.pdf; Materials - Woods: http://www.viccarbe.com/archivos/VICCARBE_woods_maderas.pdf
Type - Other - Category: Furniture; Composition 1: no; Composition 2: yes; Composition 3: no; Composition 4: no; Composition 5: no; Family Name: 2015_Table_Viccarbe_Maarten-Composition
Pset_ManufacturerTypeInformation - Manufacturer: VICCARBE
Cantidades de mobiliario - Descripción de unidad: 2015_Table_Viccarbe_Maarten-Composition: COMPOSITION 2; Tipo: 2015_Table_Viccarbe_Maarten-Composition: COMPOSITION 2; Descripción: Table system is based on a technical minimalist leg solution that does not need a structure and can be attached directly to the table top. Having no structure and a table top thickness of just 5 mm it acquires great visual lightness. There are endless uses, finishes and formats with this innovative system. Its “one mile” concept expresses how it can be used for breakfast in the kitchen, then working in the office, for eating in its restaurant version and later on for a meeting around it as a boardroom table and finally for dinner in the evening.; Fabricante: VICCARBE; Modelo: COMPOSITION 2; URL: http://www.viccarbe.com/
Constraints - Host: Level : Nivel 1; Level: Level: Nivel 1; Moves With Nearby Elements: no; Offset: 0 mm
Dimensions - Area: 53.565 m2; Volume: 0.56427 m3
Other - Family: 2015_Table_Viccarbe_Maarten-Composition: COMPOSITION 2; Family and Type: 2015_Table_Viccarbe_Maarten-Composition: COMPOSITION 2; Type: 2015_Table_Viccarbe_Maarten-Composition: COMPOSITION 2; Type Id: 2015_Table_Viccarbe_Maarten-Composition: COMPOSITION 2
Phasing - Phase Created: Fase 1
